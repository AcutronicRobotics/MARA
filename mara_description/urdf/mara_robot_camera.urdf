Commit message: add radius to dummy sphere

File: mara_description/urdf/mara_robot_camera.urdf (robot description, URDF)
Before this commit: robot mara, 22 links, 21 joints
Links:
- link motor6_link: geometry collision sphere radius=0.01; visual sphere radius=0.01
